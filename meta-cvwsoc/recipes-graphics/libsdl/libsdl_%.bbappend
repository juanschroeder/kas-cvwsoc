
EXTRA_OECONF:append = " --enable-oss"

